# Keil uVision project SWAuthDemo.uvprojx, settings and files
target iflash_lpcxpresso_1125 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWAuthDemo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o ./keil_output/@L.bin ./keil_output/@L.axf
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_112x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_112x\config_112x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_112x\nxp_lpcxpresso_1125;.\CRC16;.\Air202;.\cJSON
  asm define: CORE_M0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group SWAuthDemo
    ../../../../startup_code/: keil_startup_lpc112x.s
    ./../../../../startup_code/: sysinit.c
    ../../../../examples/periph/periph_blinky/: readme.txt
    ./: SWAuthDemo.c
  group crc16
    ./CRC16/: lib_crc16.h lib_crc16.c
  group Air202
    ./Air202/: Air202.c Air202.h
  group drivers
    ../../../../../../software/lpc_core/lpc_chip/chip_112x/: adc_112x.c chip_112x.c clock_112x.c gpio_112x.c i2c_112x.c i2cm_112x.c iocon_112x.c pmu_112x.c romdiv_112x.c ssp_112x.c syscon_112x.c sysinit_112x.c timer_112x.c uart_112x.c wwdt_112x.c
    ../../../../../../software/lpc_core/lpc_chip/chip_common/: ring_buffer.c
  group board
    ../../../../../../software/lpc_core/lpc_board/boards_112x/nxp_lpcxpresso_1125/: board.c board_sysinit.c
  group cJSON
    ./cJSON/: cJSON.c
software components: CMSIS:CORE 5.0.1
